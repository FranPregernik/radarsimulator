IMAGE_INSTALL_append = " eth01-config"
