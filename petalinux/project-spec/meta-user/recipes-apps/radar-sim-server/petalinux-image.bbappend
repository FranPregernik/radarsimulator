IMAGE_INSTALL_append = " radar-sim-server"
