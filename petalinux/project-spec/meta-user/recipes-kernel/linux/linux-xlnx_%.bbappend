SRC_URI += "file://user_2017-01-19-17-34-00.cfg;subdir=git"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

